options:
  parameters:
    description: Minimal cyber_range showcase - drag the slider and watch the tone sweep across the spectrum and waterfall.
    device: Auto
    generate_options: cyberether_gui
    generator_class_name: CyberetherStandaloneGuiGenerator
    generator_module: gnuradio.cyberether.workflows.cyberether_standalone_gui
    id: slider_demo
    output_language: python
    title: Slider demo
  states: {}

blocks:
- name: freq
  id: cyberether_cyber_range
  parameters:
    label: range
    start: '-100e3'
    stop: 100e3
    value: 10e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: cyberether_cyber_lineplot_sink_0
  id: cyberether_cyber_lineplot_sink
  parameters:
    buffer_size: '4096'
    display: Frequency
    gui_hint: '"0, 0"'
    name: '"spectrum"'
    type: complex
  states: {}
- name: cyberether_cyber_waterfall_sink_0
  id: cyberether_cyber_waterfall_sink
  parameters:
    display: Frequency
    fft_size: '1024'
    gui_hint: '"1, 0"'
    height: '256'
    name: '"waterfall"'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', cyberether_cyber_lineplot_sink_0, '0']
- [blocks_throttle2_0, '0', cyberether_cyber_waterfall_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1100-gf06564b3
