options:
  parameters:
    description: Four digital modulations rendered by four constellation sinks in one window - BPSK, QPSK, 8-PSK, 16-QAM - each with the same additive noise, showing the constellation-density/noise trade-off.
    device: Auto
    generate_options: cyberether_gui
    id: all_constellations_demo
    output_language: python
    title: All constellations demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: noise_amp
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    comment: One channel simulator, fanned out to all four chains.
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '8192'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_1
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '8192'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_2
  id: analog_random_source_x
  parameters:
    max: '8'
    min: '0'
    num_samps: '8192'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_3
  id: analog_random_source_x
  parameters:
    max: '16'
    min: '0'
    num_samps: '8192'
    repeat: 'True'
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: 1 bit/symbol.
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[1+0j, -1+0j]'
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: 2 bits/symbol.
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
  states: {}
- name: digital_chunks_to_symbols_xx_2
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: 3 bits/symbol.
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[1, 0.707+0.707j, 1j, -0.707+0.707j, -1, -0.707-0.707j, -1j, 0.707-0.707j]'
  states: {}
- name: digital_chunks_to_symbols_xx_3
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: 4 bits/symbol, unit average energy.
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[(a+b*1j)/(10**0.5) for a in (-3,-1,1,3) for b in (-3,-1,1,3)]'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_2
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_3
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_3
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: cyberether_cyber_constellation_sink_0
  id: cyberether_cyber_constellation_sink
  parameters:
    buffer_size: '2048'
    gui_hint: '"0, 0"'
    name: '"BPSK (1 bit/sym)"'
  states: {}
- name: cyberether_cyber_constellation_sink_1
  id: cyberether_cyber_constellation_sink
  parameters:
    buffer_size: '2048'
    gui_hint: '"0, 1"'
    name: '"QPSK (2 bits/sym)"'
  states: {}
- name: cyberether_cyber_constellation_sink_2
  id: cyberether_cyber_constellation_sink
  parameters:
    buffer_size: '2048'
    gui_hint: '"1, 0"'
    name: '"8-PSK (3 bits/sym)"'
  states: {}
- name: cyberether_cyber_constellation_sink_3
  id: cyberether_cyber_constellation_sink
  parameters:
    buffer_size: '2048'
    gui_hint: '"1, 1"'
    name: '"16-QAM (4 bits/sym)"'
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [analog_random_source_x_1, '0', digital_chunks_to_symbols_xx_1, '0']
- [analog_random_source_x_2, '0', digital_chunks_to_symbols_xx_2, '0']
- [analog_random_source_x_3, '0', digital_chunks_to_symbols_xx_3, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_throttle2_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', blocks_throttle2_1, '0']
- [digital_chunks_to_symbols_xx_2, '0', blocks_throttle2_2, '0']
- [digital_chunks_to_symbols_xx_3, '0', blocks_throttle2_3, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle2_1, '0', blocks_add_xx_1, '0']
- [blocks_throttle2_2, '0', blocks_add_xx_2, '0']
- [blocks_throttle2_3, '0', blocks_add_xx_3, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_2, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_3, '1']
- [blocks_add_xx_0, '0', cyberether_cyber_constellation_sink_0, '0']
- [blocks_add_xx_1, '0', cyberether_cyber_constellation_sink_1, '0']
- [blocks_add_xx_2, '0', cyberether_cyber_constellation_sink_2, '0']
- [blocks_add_xx_3, '0', cyberether_cyber_constellation_sink_3, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0git
