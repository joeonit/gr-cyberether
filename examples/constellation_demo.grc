options:
  parameters:
    description: Noisy QPSK into every gr-cyberether sink type, arranged in one window with GUI hints; the constellation spans the left column.
    device: Auto
    generate_options: cyberether_gui
    generator_class_name: CyberetherStandaloneGuiGenerator
    generator_module: gnuradio.cyberether.workflows.cyberether_standalone_gui
    id: constellation_demo
    output_language: python
    title: CyberEther constellation demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.08'
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '65536'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: cyberether_cyber_constellation_sink_0
  id: cyberether_cyber_constellation_sink
  parameters:
    buffer_size: '2048'
    comment: Spans both rows of the left column.
    gui_hint: '"0, 0, 2, 1"'
    name: '"QPSK constellation"'
  states: {}
- name: cyberether_cyber_lineplot_sink_0
  id: cyberether_cyber_lineplot_sink
  parameters:
    buffer_size: '4096'
    display: Time
    gui_hint: '"0, 1"'
    name: '"scope"'
    type: complex
  states: {state: disabled}
- name: cyberether_cyber_lineplot_sink_1
  id: cyberether_cyber_lineplot_sink
  parameters:
    buffer_size: '4096'
    display: Frequency
    gui_hint: '"0, 2"'
    name: '"spectrum line"'
    type: complex
  states: {state: disabled}
- name: cyberether_cyber_waterfall_sink_0
  id: cyberether_cyber_waterfall_sink
  parameters:
    comment: Spans the bottom-right two cells.
    display: Frequency
    fft_size: '1024'
    gui_hint: '"1, 1, 1, 2"'
    height: '256'
    name: '"waterfall"'
    type: complex
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_add_xx_0, '0', cyberether_cyber_constellation_sink_0, '0']
- [blocks_add_xx_0, '0', cyberether_cyber_lineplot_sink_0, '0']
- [blocks_add_xx_0, '0', cyberether_cyber_lineplot_sink_1, '0']
- [blocks_add_xx_0, '0', cyberether_cyber_waterfall_sink_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1100-gf06564b3
