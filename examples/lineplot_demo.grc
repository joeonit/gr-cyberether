options:
  parameters:
    author: Youssef Mahmoud
    description: Feed a cosine into the CyberEther line plot sink and present it.
    generate_options: no_gui
    id: lineplot_demo
    output_language: python
    title: CyberEther Line Plot Demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '8000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: cyberether_cyber_lineplot_sink_0
  id: cyberether_cyber_lineplot_sink
  parameters:
    buffer_size: '256'
    name: '"demo"'
  states: {}
- name: snippet_present
  id: snippet
  parameters:
    code: self.cyberether_cyber_lineplot_sink_0.present()
    section: main_after_start
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', cyberether_cyber_lineplot_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
