options:
  parameters:
    author: Youssef Mahmoud
    description: Mixed-type sink demo. One complex sink (cosine + noise) and one float sink (sawtooth) share the same CyberEther window. The window also uses an explicit renderer device (Metal) instead of Auto.
    device: Metal
    generate_options: cyberether_gui
    generator_class_name: CyberetherStandaloneGuiGenerator
    generator_module: gnuradio.cyberether.workflows.cyberether_standalone_gui
    id: lineplot_types_and_device_demo
    output_language: python
    title: CyberEther Line Plot - Mixed Types + Renderer Device
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_noise_source_x_c
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_c
  id: analog_sig_source_x
  parameters:
    amp: '0.8'
    freq: '500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_f
  id: analog_sig_source_x
  parameters:
    amp: '0.9'
    freq: '1200'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_c
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_c
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_f
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: cyberether_cyber_lineplot_sink_complex
  id: cyberether_cyber_lineplot_sink
  parameters:
    buffer_size: '1024'
    name: '"cosine + noise (complex)"'
    type: complex
  states: {}
- name: cyberether_cyber_lineplot_sink_float
  id: cyberether_cyber_lineplot_sink
  parameters:
    buffer_size: '1024'
    name: '"sawtooth (float)"'
    type: float
  states: {}

connections:
- [analog_noise_source_x_c, '0', blocks_add_xx_c, '1']
- [analog_sig_source_x_c, '0', blocks_add_xx_c, '0']
- [analog_sig_source_x_f, '0', blocks_throttle2_f, '0']
- [blocks_add_xx_c, '0', blocks_throttle2_c, '0']
- [blocks_throttle2_c, '0', cyberether_cyber_lineplot_sink_complex, '0']
- [blocks_throttle2_f, '0', cyberether_cyber_lineplot_sink_float, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1100-gf06564b3
