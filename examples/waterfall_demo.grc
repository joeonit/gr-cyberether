options:
  parameters:
    author: Youssef Mahmoud
    description: Minimal waterfall demo. Multi-tone complex source feeds the CyberEther waterfall sink; Superluminal computes the FFT internally.
    device: Auto
    generate_options: cyberether_gui
    generator_class_name: CyberetherStandaloneGuiGenerator
    generator_module: gnuradio.cyberether.workflows.cyberether_standalone_gui
    id: waterfall_demo
    output_language: python
    title: CyberEther Waterfall Demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.7'
    freq: '1500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.7'
    freq: '1500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '-2200'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '-2200'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_f
  id: analog_sig_source_x
  parameters:
    amp: '0.9'
    freq: '1200'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_f
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: cyberether_cyber_lineplot_sink_float
  id: cyberether_cyber_lineplot_sink
  parameters:
    buffer_size: '1024'
    name: '"sawtooth (float)"'
    type: float
  states: {}
- name: cyberether_cyber_waterfall_sink_0
  id: cyberether_cyber_waterfall_sink
  parameters:
    fft_size: '1024'
    height: '512'
    name: '"two-tone"'
  states: {}
- name: cyberether_cyber_waterfall_sink_0_0
  id: cyberether_cyber_waterfall_sink
  parameters:
    fft_size: '1024'
    height: '512'
    name: '"two-tone two"'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '2']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0, '2']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_1_0, '0', blocks_add_xx_0_0, '1']
- [analog_sig_source_x_f, '0', blocks_throttle2_f, '0']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_add_xx_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_throttle2_0, '0', cyberether_cyber_waterfall_sink_0, '0']
- [blocks_throttle2_0_0, '0', cyberether_cyber_waterfall_sink_0_0, '0']
- [blocks_throttle2_f, '0', cyberether_cyber_lineplot_sink_float, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1100-gf06564b3
