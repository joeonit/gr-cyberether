options:
  parameters:
    author: Youssef Mahmoud
    description: Two tones plus noise into the CyberEther spectrum analyzer sink - a spectrum line above a scrolling waterfall, sharing one FFT.
    device: Auto
    generate_options: cyberether_gui
    id: spectrum_analyzer_demo
    output_language: python
    title: CyberEther spectrum analyzer demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.8'
    freq: '40000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '0.4'
    freq: '-70000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.05'
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: cyberether_cyber_spectrum_analyzer_sink_0
  id: cyberether_cyber_spectrum_analyzer_sink
  parameters:
    averaging: '1'
    fft_size: '1024'
    gui_hint: '""'
    max_hold: 'False'
    name: '"spectrum analyzer"'
    range_max: '0.0'
    range_min: '-100.0'
    waterfall_height: '512'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', cyberether_cyber_spectrum_analyzer_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0git
