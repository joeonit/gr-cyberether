options:
  parameters:
    author: Youssef Mahmoud
    description: 'Kitchen-sink demo. Four sinks in one window, exercising every new knob: complex + float type variants, Time + Frequency display, all four Operations (Real, Imaginary, Amplitude, Phase). Two complex multi-tone and two float multi-tone sources drive the four sinks via separate paths.'
    device: Auto
    generate_options: cyberether_gui
    generator_class_name: CyberetherStandaloneGuiGenerator
    generator_module: gnuradio.cyberether.workflows.cyberether_standalone_gui
    id: all_options_demo
    output_language: python
    title: CyberEther - All Options Demo (4 plots, every knob)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_noise_source_x_c
  id: analog_noise_source_x
  parameters:
    amp: '0.05'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_f
  id: analog_noise_source_x
  parameters:
    amp: '0.05'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_c1
  id: analog_sig_source_x
  parameters:
    amp: '0.7'
    freq: '800'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_c2
  id: analog_sig_source_x
  parameters:
    amp: '0.4'
    freq: '-1500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_f1
  id: analog_sig_source_x
  parameters:
    amp: '0.6'
    freq: '1200'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_f2
  id: analog_sig_source_x
  parameters:
    amp: '0.4'
    freq: '600'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_c
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_add_xx_f
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_throttle2_c
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_f
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: sink_a_complex_line_time_imag
  id: cyberether_cyber_lineplot_sink
  parameters:
    buffer_size: '1024'
    display: Time
    name: '"A_complex_line_time"'
    type: complex
  states: {}
- name: sink_b_complex_waterfall_freq_phase
  id: cyberether_cyber_waterfall_sink
  parameters:
    display: Frequency
    fft_size: '1024'
    gui_hint: 1,0,1,2
    height: '512'
    name: '"B_complex_waterfall_freq"'
    type: complex
  states: {}
- name: sink_c_float_line_freq_amp
  id: cyberether_cyber_lineplot_sink
  parameters:
    buffer_size: '1024'
    display: Frequency
    name: '"C_float_line_freq"'
    type: float
  states: {}

connections:
- [analog_noise_source_x_c, '0', blocks_add_xx_c, '2']
- [analog_noise_source_x_f, '0', blocks_add_xx_f, '2']
- [analog_sig_source_x_c1, '0', blocks_add_xx_c, '0']
- [analog_sig_source_x_c2, '0', blocks_add_xx_c, '1']
- [analog_sig_source_x_f1, '0', blocks_add_xx_f, '0']
- [analog_sig_source_x_f2, '0', blocks_add_xx_f, '1']
- [blocks_add_xx_c, '0', blocks_throttle2_c, '0']
- [blocks_add_xx_f, '0', blocks_throttle2_f, '0']
- [blocks_throttle2_c, '0', sink_a_complex_line_time_imag, '0']
- [blocks_throttle2_c, '0', sink_b_complex_waterfall_freq_phase, '0']
- [blocks_throttle2_f, '0', sink_c_float_line_freq_amp, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1100-gf06564b3
