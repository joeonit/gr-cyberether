options:
  parameters:
    author: Youssef Mahmoud
    description: Showcase of every gr-cyberether feature - all three sink types, complex and float inputs, a mosaic layout using row and column spanning, and live controls driving the flowgraph from inside the CyberEther window.
    device: Auto
    generate_options: cyberether_gui
    id: everything_demo
    output_language: python
    title: gr-cyberether showcase
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: noise_amp
  id: cyberether_cyber_range
  parameters:
    comment: Watch the constellation clusters tighten and spread.
    gui_hint: '""'
    label: noise level
    start: '0.0'
    stop: '0.6'
    value: '0.08'
  states: {}
- name: freq_offset
  id: cyberether_cyber_range
  parameters:
    comment: Slides the signal across the waterfall and spins the constellation.
    gui_hint: '""'
    label: frequency offset [Hz]
    start: '-60e3'
    stop: 60e3
    value: '0'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '65536'
    repeat: 'True'
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Unit-energy QPSK.
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Slider-driven frequency shift.
    freq: freq_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    comment: Slider-driven noise.
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: Feeds the float sink.
  states: {}
- name: cyberether_cyber_constellation_sink_0
  id: cyberether_cyber_constellation_sink
  parameters:
    buffer_size: '2048'
    comment: Spans the full left column.
    gui_hint: '"0, 0, 2, 1"'
    name: '"constellation"'
  states: {}
- name: cyberether_cyber_lineplot_sink_0
  id: cyberether_cyber_lineplot_sink
  parameters:
    buffer_size: '4096'
    display: Time
    gui_hint: '"0, 1"'
    name: '"scope"'
    type: complex
  states: {}
- name: cyberether_cyber_lineplot_sink_1
  id: cyberether_cyber_lineplot_sink
  parameters:
    buffer_size: '4096'
    display: Frequency
    gui_hint: '"0, 2"'
    name: '"spectrum"'
    type: complex
  states: {}
- name: cyberether_cyber_waterfall_sink_0
  id: cyberether_cyber_waterfall_sink
  parameters:
    comment: Spans two columns.
    display: Frequency
    fft_size: '1024'
    gui_hint: '"1, 1, 1, 2"'
    height: '256'
    name: '"waterfall"'
    type: complex
  states: {}
- name: cyberether_cyber_lineplot_sink_2
  id: cyberether_cyber_lineplot_sink
  parameters:
    buffer_size: '4096'
    comment: Float input, spans the whole bottom row.
    display: Time
    gui_hint: '"2, 0, 1, 3"'
    name: '"magnitude"'
    type: float
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', cyberether_cyber_constellation_sink_0, '0']
- [blocks_add_xx_0, '0', cyberether_cyber_lineplot_sink_0, '0']
- [blocks_add_xx_0, '0', cyberether_cyber_lineplot_sink_1, '0']
- [blocks_add_xx_0, '0', cyberether_cyber_waterfall_sink_0, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_complex_to_mag_0, '0', cyberether_cyber_lineplot_sink_2, '0']

metadata:
  file_format: 1
  grc_version: 3.11.0.0git
